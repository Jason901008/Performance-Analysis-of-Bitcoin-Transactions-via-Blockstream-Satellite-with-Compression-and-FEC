options:
  parameters:
    category: Custom
    description: DVB-S2 BCH/LDPC BER Simulation
    generate_options: qt_gui
    id: dvbs2_fec_ber
    output_language: python
    title: DVB-S2 FEC BER
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: byte_rate
  id: variable
  parameters:
    value: bitrate / 8
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: esn0_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Es/N0 (dB)
    start: '-3'
    step: '0.1'
    stop: '10'
    value: snr
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: sqrt(N0)
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: bitrate
  id: parameter
  parameters:
    label: bit rate in bps
    short_id: b
    type: intx
    value: '10000000'
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0_0_0_2_0
  id: blocks_file_sink
  parameters:
    file: /home/fb20307183/Desktop/Downloads/bitcoin2.ts
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/fb20307183/Desktop/Downloads/bitcoin.ts
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_rotator_cc_foffset_sim
  id: blocks_rotator_cc
  parameters:
    comment: Simulate frequency offset
    phase_inc: '-0.000628'
  states: {state: disabled}
- name: blocks_rotator_cc_foffset_sim_0
  id: blocks_rotator_cc
  parameters:
    comment: Simulate frequency offset
    phase_inc: '0.00000001'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '8100'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate1: C1_4
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_4
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    debug_level: '0'
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_bb_0
  id: dvbs2rx_ldpc_decoder_bb
  parameters:
    constellation: constellation
    debug_level: '0'
    framesize: frame_size
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_xfecframe_demapper_cb_0
  id: dvbs2rx_xfecframe_demapper_cb
  parameters:
    constellation: constellation
    framesize: frame_size
    rate: code_rate
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK1/4
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,6,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 13,0,1,1
    label1: BER
    max: '10'
    min: '-10'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 7,0,6,1
    label1: Input
    label2: Output
    nconnections: '2'
    size: '1024'
    srate: byte_rate
    type: float
  states: {}
- name: snr
  id: parameter
  parameters:
    label: starting SNR (or Es/N0) in dB
    type: eng_float
    value: '10'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: in_bytes
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: out_bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: out_bytes
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: in_bytes
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0, '1']
- [blocks_add_xx_0_0, '0', dvbs2rx_xfecframe_demapper_cb_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_file_source_0_0_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0_0_0_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [blocks_file_source_0_0_0_0, '0', virtual_sink_0, '0']
- [blocks_rotator_cc_foffset_sim, '0', blocks_rotator_cc_foffset_sim_0, '0']
- [blocks_rotator_cc_foffset_sim_0, '0', blocks_add_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', blocks_rotator_cc_foffset_sim, '0']
- [dtv_dvbs2_modulator_bc_0, '0', blocks_rotator_cc_foffset_sim_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', virtual_sink_0_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', blocks_file_sink_0_0_0_2_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', virtual_sink_0_0, '0']
- [dvbs2rx_ldpc_decoder_bb_0, '0', dvbs2rx_bch_decoder_bb_0, '0']
- [dvbs2rx_ldpc_decoder_bb_0, llr_pdu, dvbs2rx_xfecframe_demapper_cb_0, llr_pdu]
- [dvbs2rx_xfecframe_demapper_cb_0, '0', dvbs2rx_ldpc_decoder_bb_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_0, '0', fec_ber_bf_0, '1']
- [virtual_source_1, '0', blocks_char_to_float_0, '0']
- [virtual_source_1, '0', fec_ber_bf_0, '0']

metadata:
  file_format: 1
